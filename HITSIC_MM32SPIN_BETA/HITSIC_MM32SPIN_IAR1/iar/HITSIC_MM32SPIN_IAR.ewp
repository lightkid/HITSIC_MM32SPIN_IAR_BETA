# IAR project HITSIC_MM32SPIN_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PS MindMotion MM32SPIN27PS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; OVERTIME=0; CLOCK=8000000; DEBUG
  ICCARM.CCDiagSuppress: pa082,pe223,pe1665
  ICCARM.CCIncludePath2: ..\board; ..\CMSIS; ..\device; ..\startup; ..\drivers; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: HITSIC_MM32SPIN_IAR.srec
  ILINK.IlinkOutputFile: HITSIC_MM32SPIN_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group board
    ../board/: board.c board.h
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group device
    ../device/: HAL_device.h MM32SPIN2xx_p.h system_MM32SPIN2xx_p.c system_MM32SPIN2xx_p.h
  group drivers
    ../drivers/: delay.c delay.h dtype.h flash.c flash.h HAL_adc.c HAL_adc.h HAL_comp.c HAL_comp.h HAL_conf.h HAL_crc.c HAL_crc.h HAL_div.c HAL_div.h HAL_dma.c HAL_dma.h HAL_exti.c HAL_exti.h HAL_flash.c HAL_flash.h HAL_gpio.c HAL_gpio.h HAL_i2c.c HAL_i2c.h HAL_iwdg.c HAL_iwdg.h HAL_misc.c HAL_misc.h HAL_op.c HAL_op.h HAL_pwr.c HAL_pwr.h HAL_rcc.c HAL_rcc.h HAL_spi.c HAL_spi.h HAL_syscfg.c HAL_syscfg.h HAL_tim.c HAL_tim.h HAL_uart.c HAL_uart.h HAL_wwdg.c HAL_wwdg.h i2c.c i2c.h I2C_MPU6050.c I2C_MPU6050.h oled.c oled.h uart.c uart.h
  group source
    ../source/: main.cpp
  group startup
    ../startup/: startup_MM32SPIN2xx_p.s
